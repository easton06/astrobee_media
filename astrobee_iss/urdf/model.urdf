Commit message: krpc6 changes

File: astrobee_iss/urdf/model.urdf (robot description, URDF)
Before this commit: robot iss, 1 links, 0 joints
Links:
- link body: geometry collision mesh filename=package://astrobee_iss/meshes/jpm.dae; visual mesh filename=package://astrobee_iss/meshes/jpm.dae
